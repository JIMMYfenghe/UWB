# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c include: ..\APP;..\CMSIS;..\decadriver;..\filter;..\kalman;..\lib\inc;..\platform;..\system;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group LIB
    ../lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../system/: startup_stm32f401xx.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h stm32f4xx_it.c sys.c
  group USER
    ./: delay.c main.c arm_cortexM4lf_math.lib
  group APP
    ../APP/: dwm1000_timestamp.c oled.c dw1000.c rx_main.c tx_main.c location.c ds18b20.c MQ.c rtc_time.c timer.c adxl345.c buzzer.c FallDetection.c iic.c algorithm.c max_iic.c max30102.c
  group filter
    ../filter/: filter.c
  group kalman
    ../kalman/: kalman.c matrix.c
  group platform
    ../platform/: deca_mutex.c deca_range_tables.c deca_sleep.c deca_spi.c port.c
  group deca_driver
    ../decadriver/: deca_device.c deca_params_init.c
